# Keil uVision project ByRenato.uvproj, settings and files
target LPC17xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ByRenato +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=ByRenato.bin .\Flash\ByRenato.axf
  AfterMake: .\Utilities\Run_Get_time.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Lib\Drivers\include;.\Inc;.\Lib\Usb_Drivers\Inc;.\Lib\CLib__1_0_0_4\inc;.\Components\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x2000 size 0x7e000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group System
    ./: startup_LPC17xx.s
    ./Src/: system_LPC17xx.c
    ./src/: LPC17xx_it.c
  group User
    ./Src/: main.c User.c
    ./Components/src/: Peripheral.c
  group Develop
    ./src/: Handlers.c
    ./Src/: Dev.c build_time.c
  group CLib
    ./Lib/CLib__1_0_0_4/src/: Bool.c Button.c Bytes.c Capture.c Fifo.c Parameters.c Pulse.c Serial.c Str.c SytemTime.c Timer.c Uint32.c Utils.c
  group LPC17xx_StdPeriph_Driver
    ./Lib/Drivers/source/: lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_iap.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c lpc17xx_gpio.c
  group USB_PeriphDriver
    ./Lib/Usb_Drivers/Src/: cdcuser.c usbcore.c usbdesc.c usbhw.c usbuser.c uart.c
