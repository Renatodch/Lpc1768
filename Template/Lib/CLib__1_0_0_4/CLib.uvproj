# Keil uVision project CLib.uvproj, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L152RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CLib__1_0_0_4 (library)
  c flags: Optim=1
  c include: .\inc;.\Libraries\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Src
    ./src/: Capture.c Parameters.c Pulse.c Fifo.c Button.c
  group System
    ./src/: Str.c SytemTime.c Timer.c Bool.c Bytes.c Utils.c Uint32.c
  group Inc
    ./inc/: CLib.h
