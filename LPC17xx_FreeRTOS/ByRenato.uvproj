# Keil uVision project ByRenato.uvproj, settings and files
target LPC17xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ByRenato
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Lib\Drivers\include;.\inc;.\FreeRTOS\inc;.\FreeRTOS\Portable
  asm include: .\FreeRTOS\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group FreeRTOS
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/Portable/: port.c heap_1.c
  group System
    ./: startup_LPC17xx.s
    ./src/: system_LPC17xx.c
  group User
    ./src/: main.c User.c
