# Keil uVision project ByRenato.uvproj, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ByRenato
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Lib\Libs
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group CMSIS
    ./: startup_LPC17xx.s
    ./Lib/src/: system_LPC17xx.c
  group User
    ./Src/: main.c
  group USB
    ./Lib/src/: File_Config.c fs_usbh_msc.c usb_config.c usbh_ohci_lpc17xx.c
  group Libs
    ./Lib/Libs/: FS_CM3.lib USB_CM3.lib
